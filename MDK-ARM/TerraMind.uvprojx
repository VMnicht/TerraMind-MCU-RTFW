# Keil uVision project TerraMind.uvprojx, settings and files
target TerraMind (6210000::V6.21::ARMCLANG)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: TerraMind +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=9 wLevel=1
  c define: USE_HAL_DRIVER,STM32F407xx,USE_STDPERIPH_DRIVER,ARM_MATH_CM4
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include
  asm include: as above
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c can.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group App
    ../TerraMind_FW/App/: app_main.cpp app_main.h
  group Algorithm
    ../TerraMind_FW/Algorithm/: PID.cpp PID.h SuperPID.cpp SuperPID.h
  group Device
    ../TerraMind_FW/Device/: diff_chassis.cpp diff_chassis.h
  group Driver
    ../TerraMind_FW/Driver/: M3508.cpp M3508.h xbox.cpp xbox.h debug_printer.cpp debug_printer.h pwm_motor.cpp pwm_motor.h pwm_open_loop_motor.cpp pwm_open_loop_motor.h pwm_servo.cpp pwm_servo.h pwm_esc.cpp pwm_esc.h cmd_port.cpp cmd_port.h pc_protocol.cpp pc_protocol.h pc_port.cpp pc_port.h
  group BSP
    ../TerraMind_FW/BSP/: Serial_device.cpp Serial_device.h can_bsp.cpp can_bsp.h pwm_enc_bsp.cpp pwm_enc_bsp.h pwm_servo_bsp.cpp pwm_servo_bsp.h pwm_esc_bsp.cpp pwm_esc_bsp.h
  group OSAL
    ../TerraMind_FW/OSAL/: TaskManager.cpp TaskManager.h
  group Utils
    ../TerraMind_FW/Utils/: crc_util.c crc_util.h Vector2D.cpp Vector2D.h
software components: CMSIS:CORE 6.1.1, CMSIS:DSP 1.15.0
